# Keil uVision project Timer-Based LED Pattern Generator and Button Interrupt Controller [ keil project ].uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: week4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Timer-Based LED Pattern Generator and Button Interrupt Controller [ C source ].c
