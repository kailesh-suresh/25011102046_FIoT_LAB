# Keil uVision project uart Initialization And Transmission check [ keil project ].uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: week6A_MSV+A +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 uart Initialization And Transmission check [ C Source ].c
